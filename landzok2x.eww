<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\landzo K2x\landzo k2x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


