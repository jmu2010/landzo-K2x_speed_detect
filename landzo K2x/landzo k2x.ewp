# IAR project landzo k2x.ewp, settings and files
configuration KL25_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 NXP MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\src\App; ..\src\common; ..\src\cpu; ..\src\cpu\headers; ..\src\Driver\mcg; ..\src\Driver\delay; ..\src\Driver\gpio; ..\src\Driver\uart; ..\src\Driver\flash; ..\src\Driver\PIT; ..\src\Driver\ADC; ..\src\Driver\uart; ..\src\Driver\lptmr; ..\src\Driver\TPM; ..\src\Driver\spi; ..\src\Driver\i2c; ..\src\Driver\dma; ..\src\landzo\Landzo_Calculation; ..\src\landzo\Landzo_CCD; ..\src\landzo\Landzo_Electromagnetism; ..\src\landzo\Landzo_GyroAccelerate; ..\src\landzo\Landzo_Key; ..\src\landzo\Landzo_MeasureSpeed; ..\src\landzo\Landzo_Motor; ..\src\landzo\Landzo_OLED; ..\src\landzo\Landzo_Predator; ..\src\landzo\Landzo_SD; ..\src\landzo\Landzo_ServoMotor; ..\src\landzo\Landzo_Ultrasonic; ..\src\landzo\Landzo_TFTLCD; ..\src\Driver\system
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: landzo k2x.srec
  ILINK.IlinkOutputFile: landzo k2x.out
  ILINK.IlinkIcfFile: F:\SmartCar\Project\00_Software\04_PortableRemote\speed_detect\config files\linker\MKL26Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration KL25_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\config files\linker\128KB_Pflash.icf
configuration KL26_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  ICCARM.CCDefines: NDEBUG; IAR; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\config files\linker\256KB_Pflash.icf
configuration KL26_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  ICCARM.CCDefines: NDEBUG; IAR; MKL26Z4; ARM_MATH_CM0PLUS
  ILINK.IlinkIcfFile: F:\SmartCar\Project\00_Software\04_PortableRemote\speed_detect\config files\linker\256KB_Pflash.icf
  group App
    ../src/App/: isr.c main.c
  group Driver
    ../src/Driver/adc/: KL2x_adc.c
    ../src/Driver/delay/: KL2x_delay.c
    ../src/Driver/dma/: KL2x_dma.c
    ../src/Driver/Flash/: KL2x_flash.c
    ../src/Driver/gpio/: KL2x_gpio.c
    ../src/Driver/i2c/: KL2x_i2c.c
    ../src/Driver/lptmr/: KL2x_lptmr.c
    ../src/Driver/PIT/: KL2x_PIT.c
    ../src/Driver/spi/: KL2x_spi.c
    ../src/Driver/TPM/: KL2x_TPM.c
    ../src/Driver/uart/: KL2x_uart.c
  group Include
    ../src/common/: common.h include.h
    ../src/Driver/gpio/: pin_cfg.h
    ../src/Driver/system/: systemclock.h
  group Landzo Module
    ../src/landzo/Landzo_Calculation/: Landzo_Calculation.c
    ../src/landzo/Landzo_CCD/: Landzo_CCD.C
    ../src/landzo/Landzo_Electromagnetism/: Landzo_Electromagnetism.c
    ../src/landzo/Landzo_GyroAccelerate/: Landzo_GyroAccelerate.c
    ../src/landzo/Landzo_Key/: Landzo_Key.c
    ../src/landzo/Landzo_MeasureSpeed/: Landzo_MeasureSpeed.c
    ../src/landzo/Landzo_Motor/: Landzo_Motor.c
    ../src/landzo/Landzo_OLED/: Landzo_OLED.c
    ../src/landzo/Landzo_Predator/: Landzo_Predator.c
    ../src/landzo/Landzo_ServoMotor/: Landzo_ServoMotor.c
    ../src/landzo/Landzo_TFTLCD/: Landzo_TFTLCD.c
    ../src/landzo/Landzo_Ultrasonic/: Landzo_Ultrasonic.c
  group System
    ../src/cpu/: arm_cm0.c crt0.s start.c startup.c vectors.c
    ../src/Driver/system/: system.c
